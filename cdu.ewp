# IAR project cdu.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m32a ATmega32A
  ICCAVR.CCDefines: SYS_UART; SYS_TRM0; UART_DS_MODE; SPI_POOL; STABLE_ON
  ICCAVR.newCCIncludePaths: ; sys\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: sys\lnkm32as.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: m32 ATmega32
  ICCAVR.CCDefines: NDEBUG; SYS_UART; SYS_TRM0; UART_DS_MODE; SPI_POOL; STABLE_ON
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm32.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group csu
    csu/: csu.c csu.h csu_imp.h mtd.c mtd.h
  group key
    key/: key.c key.h
  group lcd
    lcd/: lcd.c lcd.h wh2004.c wh2004.h
  group net
    net/: net.c net.h net_imp.h
  group net/kron
    net/kron/: kron.c kron.h kron_imp.h
  group net/modbus
    net/modbus/: mbus.c mbus.h mbus_imp.h
  group pid
    pid/: pid_r.c pid_r.h
  group pwm
    pwm/: pwm.c pwm.h
  group spi
    spi/: spi.c spi.h spi_imp.h
  group spi/adc
    spi/adc/: ads1118.c ads1118.h ads1118_imp.h
  group sys
    sys/: config.c config.h filter.c lnkm32as.xcl main.c stime.c stime.h system.h
  group tsens
    tsens/: ds1820.c ds1820.h
